Commit message: added descriptions to drone model

File: drone_models/cf2x/cf2x.urdf (robot description, URDF)
Before this commit: robot cf2, 7 links, 6 joints
Links:
- link base_link: mass 0.027 -> 0.07
